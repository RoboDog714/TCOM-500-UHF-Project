options:
  parameters:
    author: RoboDog714
    generate_options: qt_gui
    id: RSPdx_R2_ATSC
    output_language: python
    title: UHF ATSC Receive from RSPdx-R2
  states: {}

blocks:
- name: cf
  id: variable_qtgui_entry
  parameters:
    label: Center Frequency (MHz)
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: atscTestTest.ts
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: atscSignalTest.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: samp_rate
    sps: '1.5'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '7777'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: cf
    fftsize: '8192'
    name: '"ATSC Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '8000000'
    fc: cf
    fftsize: '1024'
    name: '"ATSC Spectrum Post Pipe"'
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', dtv_atsc_rx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_atsc_rx_0, '0', blocks_char_to_float_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_rx_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
