options:
  parameters:
    author: RoboDog714
    generate_options: qt_gui
    id: RSPdx_R2_ATSC
    output_language: python
    title: UHF ATSC Receive from RSPdx-R2
  states: {}

blocks:
- name: cf
  id: variable_qtgui_entry
  parameters:
    label: Center Frequency (MHz)
    type: int
    value: '527000000'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10776000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: atscFile.ts
    type: byte
    unbuffered: 'True'
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: samp_rate
    sps: '1.1'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '7777'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '8000000'
    fc: cf
    fftsize: '8192'
    name: '"ATSC Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '8000000'
    fc: cf
    fftsize: '1024'
    name: '"ATSC Spectrum Post Pipe"'
    type: float
  states: {}
- name: sdrplay3_rspdxr2_0
  id: sdrplay3_rspdxr2
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    antenna: Antenna A
    bandwidth: 8000e3
    biasT: 'False'
    center_freq: cf
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'True'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
    showports: 'False'
    stream_tags: 'False'
    synchronous_updates: 'False'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [dtv_atsc_rx_0, '0', blocks_char_to_float_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_rx_0, '0', network_udp_sink_0, '0']
- [sdrplay3_rspdxr2_0, '0', dtv_atsc_rx_0, '0']
- [sdrplay3_rspdxr2_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
